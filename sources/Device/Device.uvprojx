# Keil uVision project Device.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LiniaD +hex
  AfterMake: fromelf.exe --bin Objects-Debug\LiniaD.axf --output LiniaD.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, STM32F407xx
  c include: .\src;.\src\libs\CMSIS;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\src\Hardware\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\src\Hardware\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\Hardware\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\sources;..
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dma.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_nor.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_usb.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_nor.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
    ../Common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c
  group libs/CDC
    ../Common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c
  group src
    ./src/: defines.h structs.h main.cpp version.cpp
  group Device
    ./src/Device/: FPGA.cpp FPGA.h Chips.cpp Chips.h Commutator.cpp Commutator.h Channels.h Sources.cpp Sources.h Device.cpp Device.h ChanB.cpp ChanS.cpp ChanC.cpp
  group Device/OPi5Plus
    ./src/Device/OPi5Plus/: OPi5Plus.cpp OPi5Plus.h SCPI.cpp SCPI.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h VCP.cpp VCP.h Bootloader.cpp Bootloader.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f407xx.s system_stm32f4xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_IT.cpp HAL_PINS.h HAL_TIM.cpp HAL_TIM2.cpp HAL_TIM3.cpp stm32f4xx_hal_conf.h HAL_PINS.cpp HAL_USART1.cpp
  group Hardware/USBD
    ./src/Hardware/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_desc.cpp usbd_desc.h usbd_core.cpp
  group Utils
    ./src/Utils/: Debug.cpp Debug.h Math.h Math.cpp Memory.cpp Memory.h Log.cpp Log.h RingBuffer.cpp RingBuffer.h BufferOSDP.cpp BufferOSDP.h StringUtils.cpp StringUtils.h
target Release (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: Linia +hex
  AfterMake: fromelf.exe --bin Objects\Linia.axf --output Linia.bin
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, STM32F407xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
