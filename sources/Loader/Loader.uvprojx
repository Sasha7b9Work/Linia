# Keil uVision project Loader.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LoaderD +hex
  AfterMake: fromelf.exe --bin Objects-Debug\LoaderD.axf --output LoaderD.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, STM32F407xx
  c include: .\src;.\src\libs\CMSIS;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\src\Hardware\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\src\Hardware\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\Hardware\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\sources;..
  memory RVCT4: ROM 0x80c0000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Loader.sct
  group libs/HAL
    ../Common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c
  group src
    ./src/: main.cpp defines.h structs.h Upgrader.cpp Upgrader.h
  group Device
    ./src/Device/: Device.cpp Device.h
  group Device/OPi5Plus
    ./src/Device/OPi5Plus/: SCPI.cpp SCPI.h OPi5Plus.cpp OPi5Plus.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f407xx.s system_stm32f4xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h HAL.cpp HAL.h HAL_USART1.cpp HAL_IT.cpp HAL_PINS.cpp HAL_PINS.h HAL_TIM.cpp HAL_TIM2.cpp HAL_TIM3.cpp HAL_FLASH.cpp
  group Utils
    ./src/Utils/: BufferOSDP.cpp BufferOSDP.h Log.cpp Log.h RingBuffer.cpp RingBuffer.h String.cpp String.h StringUtils.cpp StringUtils.h Debug.cpp Debug.h GlobalFunctions.cpp GlobalFunctions.h
target Release (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: Loader +hex
  AfterMake: fromelf.exe --bin Objects\Loader.axf --output Loader.bin
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, STM32F407xx
  c include: as above
  memory RVCT4: ROM 0x80c0000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Loader.sct
